# Keil uVision project usbd_vcp.uvprojx, settings and files
target USBD_VCP-STM32072B-EVAL (ARM-ADS)
  device: STM32F072VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F072B-EVAL
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM32072B_EVAL,USE_STDPERIPH_DRIVER,STM32F072
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32072B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ../src/: app.c stm32_it.c usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c usbd_cdc_vcp.c ServerCmd.c device.c tr_testor.c
  group USB_Class
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_Drivers
    ../../../Libraries/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Library
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32F0XX
    ../src/: system_stm32f0xx.c
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group STM32F072_StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crs.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_adc.c stm32f0xx_dac.c
software components: CMSIS:CORE 3.40.0
